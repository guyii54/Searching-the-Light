# Keil uVision project stm32.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\APP;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\SysTick;.\APP\smg;.\APP\anjian;.\APP\exti;.\APP\LED;.\APP\time;.\APP\PWM;.\APP\232;.\APP\printf;.\APP\HC_SR04;.\APP\steering;.\APP\encoder;.\APP\beep;.\APP\RF;.\APP\buffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group drive
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group APP
    ./APP/232/: usart.c
    ./APP/printf/: printf.c
    ./APP/encoder/: encoder.c
    ./APP/HC_SR04/: cs.c
    ./APP/time/: time.c
    ./APP/exti/: exti.c
    ./APP/beep/: beep.c
    ./APP/PWM/: pwm.c
    ./APP/steering/: steering.c
    ./APP/anjian/: key.c
    ./APP/LED/: LED.c
    ./APP/RF/: rf.c
    ./APP/SysTick/: SysTick.c
    ./APP/buffer/: buffer.c
